# Keil uVision project ZM470SX.uvprojx, settings and files
target LPC1114 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1114FBD48/302 NXP
  pack: Keil.LPC1100_DFP.1.0.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ZM470S +hex
  c flags: Optim=1
  c include: .\driver;.\USER_CODE;.\LPC11xx;.\ZM470SX
  asm include: .\driver;.\LPC11xx;.\USER_CODE;.\ZM470SX
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\Flash\ZM470S.sct
  group Startup Code
    ./: startup_LPC11xx.s
  group System Code
    ./: system_LPC11xx.c
  group Core Code
    ./: core_cm0.c
  group Source Code
    ./USER_CODE/: main.c note.txt
  group driver
    ./driver/: Uart.c
  group ZM470SX
    ./ZM470SX/: radio.c sx1276.c sx1276-Hal.c sx1276-LoRa.c sx1276-LoRaMisc.c
software components: CMSIS:CORE 4.3.0
